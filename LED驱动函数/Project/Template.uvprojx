# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Liabraries\CMSIS;..\Liabraries\inc;..\User;..\SYS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../Liabraries/CMSIS/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../Liabraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ../Liabraries/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h led.c leds.c
  group SYS
    ../SYS/: delay.c key.c timer3.c sys.c
